# Keil uVision project Secure.uvprojx, settings and files
target Secure (6100001::V6.10.1::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.2
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: Secure
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=5
  c define: DEBUG_PORT = UART0
  c misc: -mfloat-abi=soft -Wno-documentation -Wno-reserved-id-macro
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\M2351\Include;..\..\Library\StdDriver\inc;..\..\;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\secure.sct
  link misc: --import-cmse-lib-out ..\lib\nsclib_Secure.o
  group CMSIS
    ../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group User
    ../: main.c xom0_func.c xom1_func.c Nuvoton_M2351_crypto_aes.c Oscore_crypto.c
    ../../: partition_M2351.h
  group Library
    ../../Library/StdDriver/src/: retarget.c clk.c gpio.c crypto.c
  group include
    ../include/: Nuvoton_M2351_crypto_aes.h xom0_func.h xom1_func.h Oscore_crypto.h
